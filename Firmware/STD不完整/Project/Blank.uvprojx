# Keil uVision project Blank.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blank +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\timer;..\User\usart;..\User\encoder;..\System\delay;..\System\sys;..\System\systick;..\User\oled;..\User\i2c;..\User\pwm;..\User\pid;..\User\blue;..\User\mpu6050;..\User\mpu6050\eMPL;..\User\exti;..\User\eeprom;..\System\nvic;..\User\ultra
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group SYSTEM
    ../System/delay/: delay.c
    ../System/sys/: sys.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/usart/: bsp_usart.c
    ../User/encoder/: encoder.c
    ../User/timer/: timer.c
    ../User/oled/: oled.c
    ../User/i2c/: i2c.c
    ../User/pwm/: pwm.c
    ../User/pid/: pid.c
    ../User/blue/: blue_teeth.c
    ../User/mpu6050/: mpu6050.c mpuiic.c
    ../User/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../User/exti/: bsp_exti.c
    ../User/eeprom/: eeprom.c
    ../User/ultra/: ultra.c
    ../System/nvic/: nvic_config.c
  group DOC
    ../Doc/: readme.txt
